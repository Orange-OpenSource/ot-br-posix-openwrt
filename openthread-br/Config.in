## openthread-br/Config.in
```kconfig
config PRPL_OTBR_VENDOR_NAME
    string "Vendor name for thread discovery"
    default "OpenThread"
```
